# IAR project DFCR.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2478 NXP LPC2478
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 1
  General.FPU2: 0
  ICCARM.CCDefines: IAR_LPC_2478_STK
  ICCARM.CCIncludePath2: app; board; modules
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: LCD_Demo.out
  ILINK.IlinkIcfFile: config\LPC2478_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SDRAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR_LPC_2478_STK; SDRAM_DEBUG
  ILINK.IlinkIcfFile: config\LPC2478_SDRAM.icf
  group (top)
    ./: readme.txt
  group app
    app/: clock-arch.c cursor_arrow.c cursor_arrow.h logo.c main.c Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group board
    board/: sys.c
  group config
    config/: LPC2478_Flash.icf
  group Modules
    modules/: drv_glcd.c drv_touch_scr.c drv_touch_scr.h sdram_64M_32bit_drv.c
  group uIP
    uip/: psock.c timer.c uip.c uip_arp.c uiplib.c
  group uIP/http
    uip/httpd/: http-strings.c httpd-cgi.c httpd-fs.c httpd-fsdata.c httpd.c
